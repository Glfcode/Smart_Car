# Keil uVision project car-project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: car-project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FWlib;..\User
  group USER
    ./: STARTUP.A51
    ../User/: main.c
  group FWlib
    ../FWlib/: 12864.c direction.c pwm.c uart.c exti.c count.c
